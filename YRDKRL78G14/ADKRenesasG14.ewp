# IAR project ADKRenesasG14.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 1024
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: USE_SPI
  ICCRL78.CCIncludePath2: $PROJ_DIR$; ..; drv; applilet3_src\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f104pj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group applilet3_src
    applilet3_src/: r_cg_serial.c r_cg_serial.h r_cg_serial_user.c
  group Apps
    ../Apps/: App_Common.c App_Connect.c App_Exosite.c App_ProgramMode.c App_Startup.c Apps.h NVSettings.c NVSettings.h Wifi_Helper.c
  group CmdLib
    ../CmdLib/: AtCmdLib.c AtCmdLib.h GainSpan_SPI.c GainSpan_SPI.h novatel_cdma.c novatel_cdma.h
  group exosite
    ../: exosite.c exosite.h exosite_pal.c exosite_pal.h
  group inc
    ../inc/: common.h
  group sensors
    ../sensors/: Accelerometer.c Accelerometer.h LightSensor.c LightSensor.h Potentiometer.c Potentiometer.h Temperature.c Temperature.h
  group YRDKRL78G14/drv
    drv/: ADC.c ADC.h I2C.c I2C.h led.c led.h RDKRL78_spi.c RDKRL78_spi.h SAU.h SPI _G14.c SPI.h Timer.c Timer.h UART0.c UART0.h UART2.c UART2.h
  group YRDKRL78G14/drv/Glyph
    drv/Glyph/: Glyph_API.h glyph_cfg.h glyph_register.c glyph_types.h lcd.c lcd.h RL78GlyphLib_Debug.r87
  group YRDKRL78G14/drv/Glyph/Drivers
    drv/Glyph/Drivers/: ST7579_LCD.h
  group YRDKRL78G14/init
    init/: hwsetup.c hwsetup.h
  group YRDKRL78G14/system
    system/: console.c console.h EEPROM.c EEPROM.h GainSpan_IO.c GainSpan_IO.h mstimer.c mstimer.h platform.h Switch.c Switch.h YRDKRL78G14.h
